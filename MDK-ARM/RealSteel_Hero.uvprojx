# Keil uVision project RealSteel_Hero.uvprojx, settings and files
target RealSteel_Hero (6220000::V6.22::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: RealSteel_Hero +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx,USE_PWR_LDO_SUPPLY
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../APP;../Devices/BSP;../Devices/DRIVERS;../Devices/ALGO;../Devices/BMI088/inc;../Devices/Mahony;../Devices/BMI088;../Devices/Chassis;../Devices/Gimbal;../Devices/Referee;..\Devices\rm_ui
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c memorymap.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group App
    ../APP/: Chassis_task.c imu_temp_ctrl.c Gimbal_task.c Shoot_task.c Referee_task.c
  group Devices
    ../Devices/DRIVERS/: Motor.c
    ../Devices/BMI088/: BMI088driver.c BMI088Middleware.c
    ../Devices/Chassis/: Chassis_perform.c Chassis_power_control.c
    ../Devices/Gimbal/: Gimbal_perform.c
    ../Devices/Referee/: crc_ref.c
  group BSP
    ../Devices/BSP/: bsp_usart.c can_bsp.c
    ../Devices/BMI088/: bsp_dwt.c
  group Control
    ../Devices/ALGO/: controller.c kalman_filter.c pid.c QuaternionEKF.c user_lib.c
    ../Devices/Mahony/: MahonyAHRS.c
  group UI
    ../Devices/rm_ui/: ui_interface.c ui_default_cap_0.c ui_default_chassis_1_0.c ui_default_chassis_1_1.c ui_default_clip_0.c ui_default_clip_1.c ui_default_fric_0.c ui_default_fric_1.c ui_default_static_1_0.c ui_default_static_1_1.c ui_default_static_1_2.c ui_default_static_1_3.c ui_default_static_1_4.c ui_default_static_2_0.c ui.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.15.0
